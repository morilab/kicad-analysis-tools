# Repository morilab/kicad-analysis-tools

File README.md:

# kicad-analysis-tools

KiCad 10 の基板設計を **解析・検査** するための Python ツール集です。回路図の作図ルール検査、PCB 配置の採点、統合レビュー (kreview)、
製造データ (Gerber/drill) の LVS・DRC、差動インピーダンス計算、熱・IR ドロップ・PDN 解析を含みます。

- KiCad の `pcbnew` (SWIG) モジュールは **import しません**。`.kicad_sch` / `.kicad_pcb` は S 式として直接読み、必要なときだけ `kicad-cli` を別プロセスで呼びます。
- ライセンス: MIT (`LICENSE`)。
- 日本語のツールです (メッセージ・レポートは日本語)。

> **English summary** — A collection of analysis / verification tools for KiCad 10 projects: schematic style lint (`kicad-schlint`),
> PCB placement scoring (`pcb-score`), an integrated design-review runner (`review` / kreview), Gerber-vs-netlist LVS (`gerber-lvs`),
> Gerber geometric DRC (`gerber-drc`), differential-impedance / USB HS signal-integrity helpers (`si`), schematic revision history sync (`revhist`),
> and board physics (thermal, IR drop, PDN; `pcb-physics`). The tools read KiCad files directly as S-expressions and call `kicad-cli` as an
> external program; they do **not** import KiCad's `pcbnew` module. Messages and reports are in Japanese. MIT licensed.

## ツール一覧

| ディレクトリ | 内容 |
|---|---|
| [`tools/kicad-schlint/`](tools/kicad-schlint/README.md) | 回路図 (`.kicad_sch`) の作図ルール検査 (ERC では見ない読みやすさ)、回路図どうしの接続比較 (netcmp)、指摘入り PNG |
| [`tools/pcb-score/`](tools/pcb-score/README.md) | PCB 配置の採点 (密度・配線長・部品間隔など) と干渉検査、比較スコア |
| [`tools/review/`](tools/review/README.md) | kreview: 回路図・設計・PCB・実装性・製造データをまとめて定量レビュー (A〜D 採点、kreview.json / kreview.md) |
| [`tools/gerber-lvs/`](tools/gerber-lvs/README.md) | Gerber/drill だけから銅の導通を求め、`kicad-cli` の IPC-D-356 と pad 単位で比較 (ショート・オープン) |
| [`tools/gerber-drc/`](tools/gerber-drc/README.md) | Gerber/drill の幾何検査 (NPTH 上の銅、外形 clearance、paste など)。ルール YAML → `.kicad_dru` 変換 |
| [`tools/si/`](tools/si/README.md) | 差動インピーダンスの 2D 断面計算、条件の総当たり表、ngspice による USB 2.0 HS のアイパターン・TDR |
| [`tools/revhist/`](tools/revhist/README.md) | `CHANGELOG.md` → 回路図の改版履歴テキスト・title_block の書き写しと一致検査 |
| [`tools/pcb-physics/`](tools/pcb-physics/README.md) | 基板の物理解析: 熱 (`thermal/`)、IR ドロップ (`irdrop/`)、熱と IR の連成 (`coupling/`)、PDN インピーダンス (`pdn/`) |

付属データ:

- `testboards/pitfall-4l/` — 正解 (期待値) 付きの 4 層試験基板 (自作、発注しない)。pcb-score・pcb-physics・kreview のテストと例に使う。
- `tools/gerber-lvs/tests/data/` — 自作の見本基板 4 枚 (usb-jtag-ft2232h・rp2040-keypad10・esp32s3-mcu-board・fpga-voice-recorder) の控え。gerber-lvs / gerber-drc のテストに使う。
- `data/signal/` — 部品の信号特性 (立ち上がり時間など) の YAML。kreview の信号特性表・リターンパス評価が使う。
- `tools/pcb-physics/data/` — 部品の熱・電気特性 YAML、基板の製造条件 YAML。

## インストール (Ubuntu 24.04 / KiCad 10.0.8 / Python 3.12)

```sh
# KiCad 10 (kicad-cli と標準ライブラリ)。公式 PPA の例:
sudo add-apt-repository ppa:kicad/kicad-10.0-releases
sudo apt update && sudo apt install kicad
# SPICE (tools/si の usb_hs_spice.py、tools/pcb-physics の pdn が使う)、PNG 変換 (任意)
sudo apt install ngspice librsvg2-bin

git clone https://github.com/morilab/kicad-analysis-tools.git
cd kicad-analysis-tools
python3 -m venv .venv && . .venv/bin/activate
pip install -r requirements.txt
```

- KiCad のライブラリが標準以外の場所にある場合は `KICAD_SHARE` (例: `/usr/share/kicad`)、`KICAD10_SYMBOL_DIR`、`KICAD10_3DMODEL_DIR` を設定します。
- `kicad-cli` がライブラリ表 (`~/.config/kicad/10.0/`) を別の HOME で使う場合は `KICAD_CLI_HOME` で指定します (未設定なら今の HOME)。
- kicad-schlint・revhist・gerber-lvs の大部分は Python 標準ライブラリ + numpy / Pillow だけで動きます。

## 使い方 (例)

```sh
# 回路図の作図ルール検査 (ERC + schlint + PNG)
tools/kicad-schlint/check.sh path/to/board.kicad_sch
python3 tools/kicad-schlint/schlint.py path/to/board.kicad_sch --json schlint.json

# PCB 配置の採点
python3 tools/pcb-score/pcb_score.py path/to/board.kicad_pcb

# 統合レビュー (プロジェクトは読むだけ。結果は --out に)
python3 tools/review/kreview.py path/to/project --gate G2 --out /tmp/kreview

# 製造データの LVS / DRC (<project>/out/gerber を検査)
python3 tools/gerber-lvs/gerber_lvs.py path/to/project board --png
python3 tools/gerber-drc/gerber_drc.py path/to/project board

# 差動インピーダンス (2 層 1.6 mm、線幅 0.3・間隔 0.15・GND 0.2)
python3 tools/si/zdiff2d.py --h 1.53 --w 0.3 --s 0.15 --g 0.2

# 熱解析 (同梱の試験基板、約 2.5 分)
python3 tools/pcb-physics/kthermal.py testboards/pitfall-4l --cond tools/pcb-physics/examples/pitfall-4l/thermal.yaml --mode artwork --grid 0.25 --out /tmp/thermal
```

詳しい使い方・出力・判定基準は各ツールの README を見てください。

## テスト

```sh
python3 tools/kicad-schlint/tests/run_tests.py        # kicad-cli があればネットリスト照合も (約 15 秒)
python3 tools/pcb-score/tests/test_score_profiles.py
python3 tools/revhist/tests/test_revhist.py
for t in tools/review/tests/test_*.py; do python3 $t; done
python3 tools/gerber-lvs/tests/test_units.py          # KiCad 不要 (約 3 秒)
python3 tools/gerber-lvs/tests/run_tests.py           # 見本基板 4 枚で正常・故障注入 (kicad-cli が要る、数分)
python3 tools/gerber-drc/tests/run_tests.py --quick   # 合成基板とルール YAML (約 2 秒)。--quick なしで全件 (約 10 分)
python3 tools/si/zdiff2d.py --selftest
(cd tools/pcb-physics && for t in analytic data grid irdrop_analytic irdrop_couple parts_series_r pdn_analytic solver thermal_edgecond; do python3 tests/test_$t.py; done)
python3 tools/pcb-physics/tests/test_outputs.py      # 同梱の試験基板で kthermal の出力一式 (約 10 分)
```

`tools/pcb-physics/tests/test_regression.py` は usb-jtag-ft2232h の特定版の基板が要るため、`--project` を渡したときだけ動きます。

## 含めていないもの

- KiCad の `pcbnew` モジュールを使うスクリプト (基板の生成・JSON 書き出しなど)。GPL の KiCad と結合するため、MIT の本リポには入れていません。
  該当機能 (`annotate_issues.py` の入力 JSON の作成、gerber-lvs の合成基板テスト) は、必要なら各自で用意してください。
- openEMS (GPL-3.0) を使う 3D 電磁界の検証スクリプト。
- KiCad 標準ライブラリ (シンボル・フットプリント・3D モデル、CC-BY-SA 4.0) のファイル。テストで使うシンボルは実行時に手元の KiCad から読みます。
- メーカーの SPICE モデル (`tools/pcb-physics/data/parts/models/README.md` に取得元)。
- ドキュメント中の `skills/…`・`notes/…` は作者の設計メモ (非公開) への参照です。

## サードパーティ

| 依存 | ライセンス | 使い方 |
|---|---|---|
| numpy / scipy | BSD-3-Clause | import |
| matplotlib | Matplotlib License (PSF 系) | import |
| Pillow | MIT-CMU (HPND) | import |
| PyYAML | MIT | import |
| pyamg (任意) | MIT | import |
| KiCad (`kicad-cli`) | GPL-3.0+ | 別プロセスとして実行するだけ (import しない) |
| ngspice | BSD-3-Clause (一部 modified BSD) | 別プロセスとして実行するだけ |

テスト用の基板ファイル (`.kicad_pcb`・`.kicad_sch`) には KiCad 標準ライブラリ由来のフットプリント・シンボルが埋め込まれています。
KiCad ライブラリのライセンス (CC-BY-SA 4.0) には、ライブラリを使って作った設計データへの例外条項があります。

## KiCad design testboards/pitfall-4l/pitfall-4l.kicad_pcb

File testboards/pitfall-4l/README.md:

# pitfall-4l — 熱・IR ドロップ・リターンパス評価ツールの回帰試験基板 (rev0.2)

「あるある失敗」を 1 枚に並べた正解付きの試験基板。pcb-physics (熱・IR ドロップ・連成) と kreview P20/P21 (リターンパス) の
回帰テスト用。**発注しない** (机上の正解表。実測するなら発注前に LCSC 番号を選ぶ)。2026-10-14 作者 承認の依頼で作成。

- 4 層: L1 信号 / L2 GND ベタ / L3 電源 (+5V_IR・+5V_LDO・+5V_RELIEF・+5V_DENSE・+5V_SPREAD に分割) / L4 信号、100 × 129 mm、1.6 mm、外層 1 oz、stackup JLC04161H-7628 (.kicad_pcb に記入)
- rev0.2: 比べる熱パターンの対 (U1/U2、密集/分散、R19/R20) は中心線 x = 50 で鏡映、発熱部品は外形から 15 mm 以上。熱の期待値は `tools/thermal_model.py` (パッド→L2 プリプレグ + L2/L3 板の 2D モデル) で計算。改版内容は CHANGELOG.md
- 部品: 負荷抵抗 (2512)・LDO (AMS1117-3.3) と必須の入出力 C・コネクタ (JST XH、キー付き) だけ
- 区画ごとに電源コネクタを分け、1 区画ずつ通電できる (熱の干渉を避ける)
- **正解表: `expected.yaml`** (パターンごとの座標・条件・期待値・計算式・根拠・許容差)

| 区画 | パターン | 場所 (基板左上原点 mm) | 期待値 (要約) |
|---|---|---|---|
| リターンパス | L2 スリット跨ぎ 幅 0.5 / 2 / 5 mm (長さ 5.5) | x 25、y 6 / 15 / 24 | 20 / 25 / 35 点 (pass / pass / warn) |
| | 層変更 via と GND via 隙間 0.5 / 2 / 5 mm (中心 1.1 / 2.6 / 5.6) | via x 76、y 4 / 11 / 19 | 7.3 / 17.3 / 37.3 点 (pass / pass / warn) |
| | アンチパッド連結の櫛 (via 9 本、ピッチ 1.2) | x 82、y 21.6〜31.2 | 36 点 (warn) |
| IR ドロップ | 細線 0.2 × 50 mm (R1) | y 34 | 122.9 mΩ、12.0 mV |
| | ベタのネック 1 × 5 mm (R2) | x 78〜83、y 35.75 | ネック 2.46 mΩ、241 µV |
| | L3→L1 via 1 / 4 / 9 本 (R3 / R4 / R5) | x 77.5 / 86 / 94.5、y 51.5 | 110 / 27.6 / 12.3 µV (via 長 = 銅中心間 1.3157 mm) |
| | 遠距離負荷 L4 1.0 × 82.5 mm (R6) | J1 → (68,55) | 40.5 mΩ、合計 4.17 mV |
| 熱 | LDO サーマルビア有 (U1) / 無 (U2)、0.535 W + 負荷 0.495 W × 4 同時 | (24,70) / (76,70) | Tj 85 (64–97) / 88 (66–101) ℃ (差 3.2 K) |
| | 発熱体 密集 (R11-14) / 分散 (R15-18)、0.49 W × 4 | 中心 (33,104) / (67,104) | pad +88.6 / +63.3 K (比 1.40) |
| | サーマルリリーフ (R19) / 直結 (R20) | (39,85) / (61,85) | GND pad どうしの最高温度の差 R19−R20 = 7.0 K (3〜11) |
| | 細線 1 A (0.3 × 30 mm、J4→J5) | y 48.5 | ΔT 4.1 K (IPC-2221 の 10 K は上限)、50.9 mV |
| 連成 | 細線 1.5 A (0.2 × 50 mm、J6→J7) | y 41 | 合否 = 収束・比 (1+αΔT、T は抵抗重み付きの実効温度 T_eff)・単調収束。参考: T_eff 42 ℃、200 mV (非連成 184 mV、+8.7%) |

## 図面 (docs/、kicad-cli で出力した PNG)

### 回路図

### 合成図 (上から見た図: F.Cu > In1.Cu (GND) > In2.Cu > B.Cu の重ね、シルク・外形付き)
B.Cu は In1.Cu の GND ベタに隠れるので、各層の図も見てください。オレンジ = In1.Cu の切れ目から見える In2.Cu。

### 各層 (AW、各層 + 外形 + F.Silkscreen)
| 層 | 図 |
|---|---|
| F.Cu (L1 信号) |  |
| In1.Cu (L2 GND、スリット・櫛) |  |
| In2.Cu (L3 電源分割) |  |
| B.Cu (L4 信号、IR4・U1 の L4 ベタ) |  |

### リターンパスのヒートマップ (kreview P20/P21、F.Cu の配線と参照層 In1.Cu GND、番号 = 点数表の順)

出し直し: `kicad-cli pcb export svg --layers "<層>,Edge.Cuts,F.Silkscreen" --mode-single --fit-page-to-board --exclude-drawing-sheet` → `rsvg-convert -b white -z 8`。回路図は `check.sh` の `png/page-1.png`。リターンパスは `kreview.py . --gate G2` の出力 `return_path_F_Cu.png`。

## 作り方・検査

回路図・PCB を作った生成スクリプト (tools/gen_sch.py・tools/build_pcb.py など、KiCad の pcbnew を使う) は本リポに含めていない。検査は:

```sh
../../tools/kicad-schlint/check.sh pitfall-4l.kicad_sch          # ERC + schlint + PNG
kicad-cli pcb drc --schematic-parity --severity-all pitfall-4l.kicad_pcb
python3 ../../tools/review/kreview.py . --gate G2                    # P20/P21 の点数が expected.yaml と合うか
```

rev0.2 の結果 (2026-10-14): ERC 0 / schlint error 0・warning 0 / DRC 0 (未接続 0、parity 0) / kreview G2 総合 A (98 点)、fail 0、warn 1 (D14: C3/C4 22 µF 6.3 V に 3.3 V = 52%)。
P20/P21 は rev0.1 と同じ 7 件・同じ点数 (expected.yaml の `kreview_rev0_1` / `kreview_rev0_2`、全件が期待値 ±2 点以内)。
基板標準ルール (外周 1 mm 以内の銅禁止は DRC copper_edge_clearance 1.0 mm、外周 3 mm 以内の部品 (コネクタ除く)・シルク同士とシルク-部品の重なりは自作スクリプトで検査): 違反 0。
熱の範囲は pcb-physics 63d05dc の結果 (モデルより 15〜25% 低い) を受けて下側を −35% に広げた (expected.yaml `tool_results_rev0_2`)。
熱の期待値は expected.yaml に手計算の根拠つきで書いてある (計算スクリプトは同梱していない)。

## 気づき (ツール側)
- 櫛 (アンチパッド連結) を via 径 0.6 で作ると、配線の真下の銅の切れ目は 0.1〜0.2 mm しかなく、kreview P20 は MIN_RUN 0.3 mm 未満として拾わない (実際の帰路は迂回する)。本基板は径 0.7 で切れ目を 0.4 mm にして検出させている。
- KiCad は未接続の内層の via pad を既定で消す (remove_unused_layers)。櫛を作るには via ごとに内層 pad を残す必要がある。
- スリットの点数は幅よりも長さ (迂回) で決まる (幅 10 倍で点数 1.75 倍)。

Parts:
C1, C2: 10uF; C_0603_1608Metric; Voltage 10V; MPN CL10A106KP8NNNC; LCSC C19702
C3, C4: 22uF; C_0805_2012Metric; Voltage 6.3V; MPN CL21A226MQQNNNE; LCSC C45783
J1: PWR_IR; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J2: RP_SLIT_IN; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical; MPN B4B-XH-A(LF)(SN)
J3: RP_SLIT_OUT; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical; MPN B4B-XH-A(LF)(SN)
J4: TH_1A_A; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J5: TH_1A_B; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J6: CP_1A5_A; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J7: CP_1A5_B; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J8: RP_VIA_IN; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical; MPN B5B-XH-A(LF)(SN)
J9: RP_VIA_OUT; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical; MPN B5B-XH-A(LF)(SN)
J10: PWR_LDO; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J11: PWR_DENSE; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J12: PWR_SPREAD; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J13: PWR_RELIEF; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
R1, R2, R3, R4, R5, R6, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20: 51; R_2512_6332Metric
R7, R8, R9, R10: 22; R_2512_6332Metric
U1, U2: AMS1117-3.3; SOT-223-3_TabPin2; MPN AMS1117-3.3; LCSC C6186

Connections:
/+3V3_A: C3.1, R7.1, R8.1, U1.2 (VO)
/+3V3_B: C4.1, R9.1, R10.1, U2.2 (VO)
/+5V_DENSE: J11.1, R11.1, R12.1, R13.1, R14.1
/+5V_IR: J1.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1
/+5V_LDO: C1.1, C2.1, J10.1, U1.3 (VI), U2.3 (VI)
/+5V_RELIEF: J13.1, R19.1, R20.1
/+5V_SPREAD: J12.1, R15.1, R16.1, R17.1, R18.1
/CP_1A5: J6.1, J6.2, J7.1, J7.2
/RP_COMB: J8.4, J9.4
/RP_SLIT_W0P5: J2.1, J3.1
/RP_SLIT_W2: J2.2, J3.2
/RP_SLIT_W5: J2.3, J3.3
/RP_VIA_G0P5: J8.1, J9.1
/RP_VIA_G2: J8.2, J9.2
/RP_VIA_G5: J8.3, J9.3
/TH_1A: J4.1, J4.2, J5.1, J5.2
GND: C1.2, C2.2, C3.2, C4.2, J1.2, J2.4, J3.4, J8.5, J9.5, J10.2, J11.2, J12.2, J13.2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, U1.1 (GND), U2.1 (GND)

Notes on the sheet:
RETURN PATH (L1 traces over L2 GND, kreview P20/P21)
J2->J3: L1 0.2 mm trace crosses L2 GND slit (length 5.5 mm), slit width 0.5 / 2 / 5 mm
J8->J9: L1 -> via -> L4, nearest GND via edge gap 0.5 / 2 / 5 mm (center 1.1 / 2.6 / 5.6 mm)
RP_COMB: L1 trace between 9 x +5V_IR vias (pitch 1.2 mm), L2 antipads merge = comb cut
Score = 1000 x D / (tr_eff x 150 mm/ns), tr = 2 ns (driver = connector, assumed). fail >= 100, warn >= 30
slit w 0.5 mm
slit w 2 mm
slit w 5 mm
GND via gap 0.5 mm
GND via gap 2 mm
GND via gap 5 mm
comb (merged antipads)
IR DROP (+5V_IR, 51R loads = 98 mA each)
R1: L1 0.2 x 50 mm thin trace R2: L1 pour with 1 x 5 mm neck
R3 / R4 / R5: fed from L3 by 1 / 4 / 9 vias R6: remote, L4 1.0 mm x 83 mm from J1
Copper rho = 1.72e-8 ohm m (20 C), 35 um outer
EXTERNAL CURRENT (thermal / coupled)
TH_1A: L1 0.3 x 30 mm, 1.0 A from J4.1 to J5.1
CP_1A5: L1 0.2 x 50 mm, 1.5 A from J6.1 to J7.1 (T -> R -> V)
Pin 2 = Kelvin sense (measure V between J4.2-J5.2 / J6.2-J7.2)
LDO THERMAL (AMS1117-3.3, 5 V -> 3.3 V, 0.30 A, Pd 0.51 W)
U1: tab copper (L1) + 9 thermal vias to L4 pour (+3V3_A) U2: same L1 copper, no vias
Load = 2 x 22R parallel (0.15 A each). theta-JA 90 C/W (AMS datasheet, SOT-223)
C1/C2 = input cap, C3/C4 = output cap (AMS1117 needs >= 22 uF for stability)
HEAT SPREAD / THERMAL RELIEF (51R = 0.49 W each)
R11-R14: dense 2x2 (pitch 9 x 6 mm) R15-R18: spread (pitch 27 x 15.5 mm)
R19: GND pad thermal relief to L1 GND pour R20: same pour, solid (full) connection
Each group has its own supply connector so they can be powered one by one
Compared pairs (U1/U2, dense/spread, R19/R20) mirrored about x=50, >=15 mm from edges, own L3 pour
改版履歴 版 / 日付 / 作成者 / 変更内容 rev0.1 2026-10-14 AI 作成 / D. Mori 承認 初版 回帰試験基板 4層 100x80mm rev0.2 2026-10-14 AI 作成 / D. Mori 承認 熱区画を左右対称化 基板100x129 L3面追加

Board: 4 copper layers, 100.0 x 129.0 mm, 39 parts (0 on the bottom side), 17 nets.

## KiCad design tools/gerber-lvs/tests/data/pre-refill-20261009/esp32s3-mcu-board/esp32s3-mcu-board.kicad_pcb

File tools/gerber-lvs/tests/data/README.md:

# 実基板テストデータ (控え)

自作の見本基板 4 枚 (usb-jtag-ft2232h・rp2040-keypad10・esp32s3-mcu-board・fpga-voice-recorder) の 2026-10-09 時点の控え。顧客の基板は含まない。ここのファイルは編集しない。

| ディレクトリ | 内容 |
|---|---|
| `current/<基板>/` | 4 基板 (usb-jtag-ft2232h 2 層、rp2040-keypad10 4 層、esp32s3-mcu-board 2 層、fpga-voice-recorder 4 層) の 2026-10-09 11:48 の控え。正常系・故障注入・合成のテストに使う |
| `pre-refill-20261009/<基板>/` | 同日の zone refill 前の控え。usb-jtag-ft2232h は古いベタ (J1 の NPTH 上の銅、外形 clearance 不足) が残っていて、補助検査 (`--aux`) の回帰テストに使う。ほかの 3 基板は current とほぼ同じ (.kicad_pro の DRC 重大度、fpga の部品 1 個の 3D モデル回転だけ違う) が控えとして残す |

- 各基板にあるのは `<基板>.kicad_pcb`、`<基板>.kicad_pro`、`ref.d356` (`kicad-cli pcb export ipcd356` の結果) だけ。
  元の控えにあった `ft.d356` / `old.d356` は `ref.d356` と同じ内容なので入れていない。`.kicad_prl` (表示状態だけ)、gerber の故障注入の古い手作業結果 (`inject/`、`inject4/`) も入れていない。
- `gerber/` は `tests/regen_testdata_gerbers.sh` の生成物 (git に入れない)。zone の refill はしないので、控えに保存された fill のまま出る。

Board: 2 copper layers, 30.5 x 57.0 mm, 20 parts (0 on the bottom side), 46 nets.

Parts:
C1, C3: 10uF; C_0603_1608Metric
C2: 22uF; C_0805_2012Metric
C4: 100nF; C_0402_1005Metric
C5: 1uF; C_0402_1005Metric
D1: RED; LED_0603_1608Metric
D2: GREEN; LED_0805_2012Metric
J1: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: J2 GPIO; PinHeader_1x20_P2.54mm_Vertical
J3: J3 GPIO; PinHeader_1x20_P2.54mm_Vertical
R1, R2: 5.1k; R_0402_1005Metric
R3, R5: 1k; R_0402_1005Metric
R4: 10k; R_0402_1005Metric
SW1: RESET; SW_Push_1P1T_XKB_TS-1187A
SW2: BOOT; SW_Push_1P1T_XKB_TS-1187A
U1: ESP32-S3-WROOM-1U-N8; ESP32-S3-WROOM-1U
U2: USBLC6-2SC6; SOT-23-6
U3: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C2.1, C3.1, C4.1, J2.1, J3.19, R3.1, R4.1, U1.2, U3.2
/CC1: J1.A5, R1.1
/CC2: J1.B5, R2.1
/EN: C5.1, J2.2, R4.2, SW1.1, U1.3
/IO0: J3.13, SW2.1, U1.27
/IO1: J3.3, U1.39
/IO2: J3.4, U1.38
/IO3: J2.12, U1.15
/IO4: J2.3, U1.4
/IO5: J2.4, U1.5
/IO6: J2.5, U1.6
/IO7: J2.6, U1.7
/IO8: J2.11, U1.12
/IO9: J2.13, U1.17
/IO10: J2.14, U1.18
/IO11: J2.15, U1.19
/IO12: J2.16, U1.20
/IO13: J2.17, U1.21
/IO14: J2.18, U1.22
/IO15: J2.7, U1.8
/IO16: J2.8, U1.9
/IO17: J2.9, U1.10
/IO18: J2.10, U1.11
/IO21: J3.17, R5.1, U1.23
/IO35: J3.12, U1.28
/IO36: J3.11, U1.29
/IO37: J3.10, U1.30
/IO38: J3.9, U1.31
/IO39: J3.8, U1.32
/IO40: J3.7, U1.33
/IO41: J3.6, U1.34
/IO42: J3.5, U1.35
/IO45: J3.14, U1.26
/IO46: J3.18, U1.16
/IO47: J3.16, U1.24
/IO48: J3.15, U1.25
/LED_A: D2.2, R5.2
/PWR_LED: D1.2, R3.2
/RXD0: J3.2, U1.36
/TXD0: J3.1, U1.37
/USB_DN: U1.13, U2.6
/USB_DN_C: J1.A7, J1.B7, U2.1
/USB_DP: U1.14, U2.4
/USB_DP_C: J1.A6, J1.B6, U2.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1, D2.1, J1.A1, J1.A12, J1.B1, J1.B12, J1.SH, J2.20, J3.20, R1.2, R2.2, SW1.2, SW2.2, U1.1, U1.40, U1.41, U2.2, U3.1
VBUS: C1.1, J1.A4, J1.A9, J1.B4, J1.B9, J2.19, U2.5, U3.3

## KiCad design tools/gerber-lvs/tests/data/pre-refill-20261009/fpga-voice-recorder/fpga-voice-recorder.kicad_pcb

File tools/gerber-lvs/README.md (part):

# gerber-lvs — 製造データ (Gerber/drill) の銅の導通を KiCad の正解接続と比べる

製造データ (銅層 Gerber + Excellon、補助で Paste) だけから実際の銅の導通を求める。
それを KiCad の正解接続 (`kicad-cli pcb export ipcd356`) と **pad 単位で** 比べ、ショート・オープンを出す。
DRC の schematic parity は `.kicad_pcb` しか見ないので、zone の fill を保存し忘れて古い fill のまま
gerber を出した、といった「出来上がった gerber の誤り」は分からない。このツールは gerber を独立に検査する

- system `python3` + numpy + Pillow だけで動く (pcbnew SWIG・shapely・scipy は不要)。KiCad 10.0.7 の出力で確認。
- 元の `.kicad_pcb` は読むだけ。IPC-D-356 は一時ディレクトリにコピーしてから出す。
- 速さ: 2 層 54×36 mm で約 1 s、4 層 92×77 mm で約 3.5 s、最大メモリ約 210 MB (10 µm/px)。

| ファイル | 内容 |
|---|---|
| `gerber_lvs.py` | コマンド本体 (検査、txt/json/PNG の出力) |
| `gerberlib.py` | Gerber (RS-274X/X2) / Excellon / IPC-D-356 の読み込み、ラスタ化、run 単位の連結成分 |
| `tests/run_tests.py` | 回帰テスト (正常 4 基板、refill 前の FT2232H、故障注入、合成基板) |
| `tests/testdata.py` | 実基板テストデータの場所 (`tests/data/`) と gerber の用意 (gerber-drc のテストからも使える) |
| `tests/regen_testdata_gerbers.sh` | 控えの `.kicad_pcb` から `tests/data/*/<基板>/gerber/` を出し直す (refill なし) |
| `tests/data/` | 実基板の控え (`current/`、`pre-refill-20261009/`)。由来は `tests/data/README.md` |

## 使い方

```sh
T=tools/gerber-lvs   # リポジトリのルートから
python3 $T/gerber_lvs.py <project_dir> [<name>]          # <dir>/out/gerber (無ければ最新の out/<rev>/gerber) を検査
python3 $T/gerber_lvs.py <project_dir> <name> --png      # error の切り抜き PNG も出す
python3 $T/gerber_lvs.py --gerber-dir G --d356 X.d356 [--pro P.kicad_pro] --out-dir O   # PCB を使わない場合
```

- 出力は gerber ディレクトリの親 (`out/` か `out/<rev>/`) に `gerber_lvs.txt` (日本語)、`gerber_lvs.json`、`gerber_lvs/NN_<code>_<layer>.png` (`--png` を付けたとき)。
  PNG の切り抜きは最大 40 mm 角。pad どうしが 40 mm より離れた OPEN/SHORT は印 (`at`) の周りで切り、finding に `png_crop` ([x0, y0, x1, y1]) を付ける。PNG の作図で例外が出ても txt/json は出し、`notes` に残す (終了コードは検査結果どおり。2026-10-16)。
- 終了コード: **0** = error 0 件、**1** = error あり (`--strict` を付けると warning も 1)、**2** = 実行できなかった (ファイルが無い、未対応の構文、drill と D356 の穴位置が合わない など)。
- `--json PATH`: JSON の出力先を指定する (`--out-dir` が無ければ txt と PNG も同じディレクトリ)。JSON には kreview F09 互換の `status` (`ok`/`fail`)・`shorts`・`opens` も入る。
  kreview から使うときは `KREVIEW_LVS_CMD="python3 tools/gerber-lvs/gerber_lvs.py"` を設定する (kreview は `--json <out>/lvs.json <project_dir>` を付けて呼ぶ)。
- 座標は `gerber(x, y)` (Gerber の座標。aux 原点基準で Y は上向き) と `kicad(x, y)` (PCB エディタの座標) の両方で出す。
- 規則は `.kicad_pro` の `min_copper_edge_clearance` と `min_hole_clearance` を使う。`--edge-clearance` / `--hole-clearance` で上書きできる。
  ラスタの誤差 (許容誤差 2 px + 5 µm = 0.025 mm) を差し引いて判定する。
- `--px` で解像度を変えられる (既定 0.01 mm/px)。

## DRC 系の補助検査の移設 (2026-10-14、作者承認)

LVS (ネットリストとアートワークの等価性) に絞るため、幾何の検査 `COPPER_OVER_NPTH` / `NPTH_CLEARANCE` / `EDGE_CLEARANCE` /
`COPPER_OUTSIDE_BOARD` / `PASTE_WITHOUT_COPPER` / `OUTLINE_OPEN` は `tools/gerber-drc/gerber_drc.py` に移した
(gerberlib はこのリポジトリのものを参照して使う)。

- gerber-lvs の既定は **補助検査なし** (`--no-aux`)。旧動作は `--aux`。JSON に `aux_checks` (true/false) を出す。
- kreview は F09 = gerber-lvs、F11 = gerber-drc。
- 移設の同一性は gerber-drc のテストで確認 (gerber-lvs `--aux` と検出が完全一致: 正常 4 枚 0 件、refill 前 FT2232H 12 件)。
- 下の表の補助検査の行は `--aux` のときだけ出る。

## 検査項目

| code | 重大度 | 内容 |
|---|---|---|
| `SHORT` | error | 1 つの銅の島に別ネットの pad が載っている。X2 の `%TO.N` があれば接触点も出す |
| `OPEN` | error | 同じネットの pad が別々の島に分かれている (`unconnected-*` と `N/C` は対象外) |
| `NO_COPPER_AT_PAD` | error | SMD pad の位置にその層の銅が無い |
| `MISSING_HOLE` | error | スルー pad / via の位置にめっき穴が無い (via の消失。ステッチ via のようにネットが切れない場合もこれで分かる) |
| `NO_COPPER_AT_HOLE` | error | めっき穴はあるが、どの層にも銅が無い |
| `COPPER_OVER_NPTH` | error | NPTH の穴の中に銅がある (穴あけ前の銅で判定) |
| `EDGE_CLEARANCE` | error | 銅と Edge_Cuts (外形・内部の切り欠き) の距離が規則より小さい。1 mm の塊ごとに最小値を出す |
| `COPPER_OUTSIDE_BOARD` | error | 外形の外、または切り欠きの中に銅がある |
| `NPTH_CLEARANCE` | warning | NPTH の穴縁から銅までが `min_hole_clearance` より小さい |
| `PASTE_WITHOUT_COPPER` | warning | paste の開口の下に銅が無い |
| `EXTRA_HOLE` / `MISSING_NPTH` / `HOLE_SIZE_MISMATCH` | warning | drill と IPC-D-356 で穴が合わない |
| `PAD_AMBIGUOUS` / `NC_PAD_CONNECTED` / `NET_CASE_COLLISION` / `OUTLINE_OPEN` | warning | 判定があいまい、またはネット名の問題 |
| `LAYER_MISSING` | error | 銅層 Gerber の欠落 (FileFunction の層番号に抜け、または drill の層範囲より銅層が少ない)。2026-10-14 追加 |
| `LAYER_NAME_MISMATCH` | error | ファイル名 (F_Cu/In<n>_Cu/B_Cu) と中身の `%TF.FileFunction,Copper,L<n>` が合わない (層の取り違え)。2026-10-14 追加 |
| `PAD_COPPER_INCOMPLETE` | warning | SMD pad の中心の内接正方形 (一辺 = 短辺/√2) の銅が 90% 未満 (pad が消えて配線の端だけ残った / 別の層に出た)。via-in-pad は除外。2026-10-14 追加 |
| `LAYER_OFFSET` | error | 1 つの銅層だけ pad/ランドの flash が drill の穴から同じ向きにずれている (その層だけ原点・座標形式が違う)。ずれ量も出す。2026-10-14 追加 |
| `GBRJOB_MISMATCH` | error / warning | `.gbrjob` と合わない: 層数、job にある銅層・外形のファイルが無い、層機能 (FileFunction) が中身と違う、銅層が負極性 (error)。銅以外のファイルが無い・銅層が job に載っていない (warning)。2026-10-14 追加 |
| `X2_NET_DIFFERS` | info | pad の正解のネットが、その銅の Gerber X2 ネット属性 (`%TO.N`) に無い (gerber が古い・ネット名変更の反映漏れの説明用)。SHORT には `x2_nets`、OPEN には `x2_nets_per_group` も付ける。**正解には使わない** (検査対象自身の属性なので)。2026-10-14 追加 |
| `FLOATING_COPPER` | info | どの pad にもつながらない銅の島 (大きい順に 10 個まで) |

## 方式

1. **正解**: `kicad-cli pcb export ipcd356`。317 = スルー (穴径・PTH/NPTH 付き)、327 = SMD、367 = NPTH、`VIA` レコードあり。
   access コードは銅層の番号 (A01 = 表、2 層の裏 = A02、4 層の裏 = A04、A00 = スルー)。
   ネット名は 14 文字までで大文字になる。長い名前は `NNAME` の別名になるので、別名を元の名前に戻してから大文字小文字を無視して比べる。
2. **原点**: drill の穴と D356 のスルー pad/via の位置を突き合わせて、ずれを多数決で求めて補正する (make_out.sh の出力ではずれ 0)。
   一致が半分未満なら別の基板とみなして終了コード 2。
3. **銅**: 各層を 10 µm/px で描画する (G36 region の cut-in、RoundRect などのマクロ、円弧、LPC に対応)。
   NPTH の検査をしてから全穴 (PTH/NPTH、G85 と M15/M16 の長穴) を抜く → 行ごとの run にして 4 近傍で union (numpy でベクトル化)。
   画像は帯 (512 行) ごとに読んで run だけを残す。
4. **層間**: めっき穴の壁 (半径 d/2 + 2 px) に触れる各層の島を、その穴を介して 1 つにまとめる。drill の FileFunction の層範囲を見るので、ブラインド/ベリードの drill ファイルにも対応する。
   NPTH は抜くだけ (つながない)。サーマルリリーフは KiCad が zone の region として出すので、特別扱いは要らない。
5. **pad の対応**: SMD は access 層の pad 中心の島。中心に銅が無ければ (via in pad など) pad 寸法の 0.25 倍、0.45 倍の円で探す。スルー/via は同じ位置 (±0.02 mm) のめっき穴。
6. **外形**: Edge_Cuts の線分をつないで閉路を作り、入れ子の深さで外形と切り欠きを塗り分ける。外形 clearance は、帯の中の銅画素から外形線分までの距離を厳密に計算する。
7. **short の位置**: Gerber X2 のネット属性 (`%TO.N`) で「そのネットの銅」と「ほかの銅」を描き分け、両者が接する画素を出す。
   **X2 の属性は正解には使わない** (検査対象そのものなので)。位置の説明に使うだけ。

## テスト

```sh
python3 tests/test_units.py           # 高速スイート (KiCad 不要、約 3 s): Gerber 構文の単体・Excellon/D356・手書き合成基板の LVS
python3 tests/run_tests.py            # 完全スイート (約 2.5 分、高速スイートも含む)。--quick で件数を減らす、--only units normal old inject input synth で選ぶ
GLVS_PROJECTS=<案件の親ディレクトリ> python3 tests/run_tests.py --only normal   # 今の案件の gerber で正常確認
```

- 既定のデータはリポジトリ内の `tests/data/current/<基板>/` (4 基板の 2026-10-09 11:48 の控え。案件は作業中に動くので控えを使う)。
  refill 前の FT2232H は `tests/data/pre-refill-20261009/usb-jtag-ft2232h/` (`GLVS_OLD_FT` で上書き)。場所は `tests/testdata.py` にまとめてある
  (`GLVS_DATA` で tests/data ごと、`GLVS_PROJECTS` で 4 基板のディレクトリを差し替え)。
- git に入れるのは控えの `.kicad_pcb` / `.kicad_pro` / `ref.d356` だけ。gerber/drill は `<基板>/gerber/` に生成して `.gitignore`。
  無ければ `run_tests.py` が `tests/regen_testdata_gerbers.sh` で自動で出し直す (`GLVS_NO_REGEN=1` で止める)。手で出すなら
  `bash tests/regen_testdata_gerbers.sh [--force]`。
  設定は make_out.sh と同じで **zone の refill はしない** (refill 前の FT2232H の古いベタを再現するため)。控えの `.kicad_pcb` は書き換えない。
- 故障注入 (gerber のコピーを改変):
  - 配線区間を 1 本消す → `OPEN`
  - 近い別ネット pad 間に 0.15 mm の線、または丸い銅を足す → `SHORT`
  - via の穴だけ、または穴と via pad を消す → `MISSING_HOLE`
  - 部品のスルー穴を消す → `MISSING_HOLE`

  配線削除は、**消す区間の中心線がほかの銅 (pad の角丸や重なった配線) で全部覆われているものは「幾何的につながったまま」として先に除外し、件数を記録する**。
- 合成基板 (`make_synth.py` でコピーを改変して KiCad で出力。`make_synth.py` は KiCad の pcbnew を使うため本リポに含めない。自分で用意して `GLVS_MAKE_SYNTH` と `GLVS_APPRUN` で渡したときだけ実行し、無ければ省略):
  - C1 を裏返した 2 層/4 層 → access コードの確認
  - 1.5 mm 角の内部切り欠き → 正しく refill した出力は error 0、Edge_Cuts だけ新しい古い gerber は `COPPER_OUTSIDE_BOARD`

- 高速スイート `tests/test_units.py` + `tests/synthboard.py` (2026-10-14 追加): Gerber/drill/IPC-D-356 を手書きで作るので、正解と製造データを別々に壊せる。
  - 構文: 各 aperture (C/R/O/P/マクロ)・線・region・G02/G03/G75 円弧・LPC・穴付き aperture・インチ単位を既知の面積/画素で比較、未対応構文 (SR/G74/thermal/LM/G91/FSTAX/%MO なし) が Unsupported になること
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
Board: 4 copper layers, 90.0 x 75.0 mm, 75 parts (0 on the bottom side), 57 nets.

Parts:
C1, C20, C22, C34, C41, C44, C51, C53: 10uF; C_0603_1608Metric
C2, C21: 22uF; C_0805_2012Metric
C23, C24, C30, C31, C32, C33, C35, C36, C37, C38, C39, C40, C45, C48, C49, C52, C54: 100nF; C_0402_1005Metric
C42, C43, C46, C47, C50: 1uF; C_0402_1005Metric
D1, D2: RED; LED_0603_1608Metric
FB2: 600R@100MHz; L_0603_1608Metric
J1: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J4: JTAG; PinHeader_1x06_P2.54mm_Vertical
J5: OLED; PinSocket_1x04_P2.54mm_Vertical
J6: SPEAKER; CONN-SMD_PH2.0-1X2PW
MK1: ECM; PinHeader_1x02_P2.54mm_Vertical
R1, R2: 5.1k; R_0402_1005Metric
R3, R39: 1k; R_0402_1005Metric
R20: 33; R_0402_1005Metric
R21, R22, R23, R24, R25, R27, R28, R30, R31, R32, R33, R34, R35: 10k; R_0402_1005Metric
R26: 2.2k; R_0402_1005Metric
R29: 100k; R_0402_1005Metric
R37, R38: 4.7k; R_0402_1005Metric
SW1: REC; SW_Push_1P1T_XKB_TS-1187A
SW2: PLAY; SW_Push_1P1T_XKB_TS-1187A
SW3: UP; SW_Push_1P1T_XKB_TS-1187A
SW4: DOWN; SW_Push_1P1T_XKB_TS-1187A
SW5: RECONFIG; SW_Push_1P1T_XKB_TS-1187A
U1: GW1NR-LV9QN88PC6/I5; QFN-88_L10.0-W10.0-P0.40-BL-EP7.0
U2: USBLC6-2SC6; SOT-23-6
U3: AMS1117-3.3; SOT-223-3_TabPin2
U5: AMS1117-1.2; SOT-223-3_TabPin2
U6: ES8311; WQFN-20_L3.0-W3.0-P0.40-BL-EP1.7
U7: NS4150B; MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL
U8: TF-01A; TF-SMD_TF-01A
X1: 27MHz; OSC-SMD_4P-L3.2-W2.5-BL

Connections:
+1V2: C21.1, C30.1, C31.1, C32.1, C33.1, C34.1, U1.1, U1.22, U1.45, U1.66, U5.2
+3V3: C2.1, C20.1, C24.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C45.1, C53.1, C54.1, FB2.1, J4.1, J5.2, R3.1, R21.1, R22.1, R23.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R37.1, R38.1, R39.1, U1.12, U1.23, U1.44, U1.58, U1.64, U1.67, U1.78, U3.2, U5.3, U6.3, U6.4, U8.4, X1.1, X1.4
/ADCVREF: C43.1, U6.15
/AMP_BYP: C50.1, U7.2
/AMP_EN: R29.1, U1.32, U7.1
/AMP_INN: R28.2, U7.4
/AMP_INN_C: C49.2, R28.1
/AMP_INP: R27.2, U7.3
/AMP_INP_C: C48.2, R27.1
/AVDD_3V3: C22.1, C23.1, FB2.2, R26.1, U6.11
/BTN_DOWN: SW4.1, U1.16
/BTN_PLAY: SW2.1, U1.14
/BTN_REC: SW1.1, U1.13
/BTN_UP: SW3.1, U1.15
/CC1: J1.A5, R1.1
/CC2: J1.B5, R2.1
/CLK27: R20.2, U1.52
/CLK27_O: R20.1, X1.3
/DACVREF: C42.1, U6.14
/DAC_OUTN: C49.1, U6.13
/DAC_OUTP: C48.1, U6.12
/DONE: R23.2, U1.10
/ECM_P: C46.1, MK1.2, R26.2
/I2C_SCL: J5.3, R37.2, U1.30, U6.1
/I2C_SDA: J5.4, R38.2, U1.31, U6.19
/I2S_ADC: U1.28, U6.7
/I2S_BCLK: U1.26, U6.6
/I2S_DAC: U1.29, U6.9
/I2S_LRCK: U1.27, U6.8
/I2S_MCLK: U1.25, U6.2
/JTAGSEL_N: R21.2, U1.4
/JTAG_TCK: J4.3, U1.6
/JTAG_TDI: J4.5, U1.7
/JTAG_TDO: J4.4, U1.8
/JTAG_TMS: J4.6, U1.5
/LED_K: D2.2, R39.2
/LED_STAT: D2.1, U1.17
/MIC_N: C47.1, U6.17
/MIC_P: C46.2, U6.18
/MODE0: R24.1, U1.88
/MODE1: R25.1, U1.87
/PWR_LED: D1.2, R3.2
/RECONFIG_N: R22.2, SW5.1, U1.9
/SD_CD: R35.2, U1.72, U8.9
/SD_CS: R30.2, U1.68, U8.2
/SD_DAT1: R33.2, U8.8
/SD_DAT2: R34.2, U8.1
/SD_MISO: R32.2, U1.71, U8.7
/SD_MOSI: R31.2, U1.70, U8.3
/SD_SCK: U1.69, U8.5
/SPK_N: J6.2, U7.5
/SPK_P: J6.1, U7.8
/USB_DN_C: J1.A7, J1.B7, U2.1
/USB_DP_C: J1.A6, J1.B6, U2.3
/VMID: C44.1, U6.16
GND: C1.2, C2.2, C20.2, C21.2, C22.2, C23.2, C24.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C47.2, C50.2, C51.2, C52.2, C53.2, C54.2, D1.1, J1.A1, J1.A12, J1.B1, J1.B12, J1.SH, J4.2, J5.1, MK1.1, R1.2, R2.2, R24.2, R25.2, R29.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U1.2, U1.21, U1.24, U1.43, U1.46, U1.65, U1.89, U2.2, U3.1, U5.1, U6.5, U6.10, U6.20, U6.21, U7.7, U8.6, U8.10, U8.11, U8.12, U8.13, X1.2
VBUS: C1.1, C51.1, C52.1, J1.A4, J1.A9, J1.B4, J1.B9, U2.5, U3.3, U7.6

## KiCad design tools/gerber-lvs/tests/data/current/usb-jtag-ft2232h/usb-jtag-ft2232h.kicad_pcb

Board: 2 copper layers, 54.0 x 36.0 mm, 40 parts (0 on the bottom side), 33 nets.

Parts:
C1: 10uF; C_0603_1608Metric
C2: 22uF; C_0805_2012Metric
C3, C14, C15: 4.7uF; C_0402_1005Metric
C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C18: 100nF; C_0402_1005Metric
C16, C17: 33pF; C_0402_1005Metric
D1: RED; LED_0603_1608Metric
FB1: 600R@100MHz; L_0603_1608Metric
J1: USB-C (USB2.0); USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: JTAG 1x8; PinHeader_1x08_P2.54mm_Vertical
J3: UART 1x5; PinHeader_1x05_P2.54mm_Vertical
R1, R2: 5.1k; R_0402_1005Metric
R3: 1k; R_0402_1005Metric
R4: 12k 1%; R_0402_1005Metric
R5, R6, R7: 10k; R_0402_1005Metric
R8: 2.2k; R_0402_1005Metric
R9, R10, R11, R12: 33; R_0402_1005Metric
U1: FT2232HL; LQFP-64_10x10mm_P0.5mm
U2: USBLC6-2SC6; SOT-23-6
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: 93LC56BT-I/OT; SOT-23-6
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V8: C6.1, C7.1, C8.1, C15.1, U1.12, U1.37, U1.49, U1.64
+3.3VA: C3.1, C4.1, C5.1, FB1.2, U1.4, U1.9
+3V3: C2.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C18.1, FB1.1, R3.1, R5.1, R6.1, R7.1, U1.14, U1.20, U1.31, U1.42, U1.50, U1.56, U3.2, U4.6
/EECS: R5.2, U1.63, U4.5
/JTAG_TCK: J2.3, R9.2
/JTAG_TDI: J2.5, R10.2
/JTAG_TDO: J2.4, R11.2
/JTAG_TMS: J2.6, R12.2
/JTAG_nSRST: J2.8, U1.22
/JTAG_nTRST: J2.7, U1.21
/UART_CTS#: J3.4, U1.41
/UART_RTS#: J3.3, U1.40
/UART_RXD: J3.2, U1.39
/UART_TXD: J3.1, U1.38
/USB_DN: U1.7, U2.6
/USB_DN_C: J1.A7, J1.B7, U2.1
/USB_DP: U1.8, U2.4
/USB_DP_C: J1.A6, J1.B6, U2.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D1.1, J1.A1, J1.A12, J1.B1, J1.B12, J1.SH, J2.2, J3.5, R1.2, R2.2, R4.2, U1.1, U1.5, U1.10, U1.11, U1.13, U1.15, U1.25, U1.35, U1.47, U1.51, U2.2, U3.1, U4.2, Y1.2, Y1.4
unnamed: D1.2, R3.2
unnamed: J1.A5, R1.1
unnamed: J1.B5, R2.1
unnamed: R9.1, U1.16
unnamed: R10.1, U1.17
unnamed: R11.1, U1.18
unnamed: R12.1, U1.19
unnamed: R6.2, U1.62, U4.4
unnamed: R7.2, R8.2, U1.61, U4.3
unnamed: C16.1, U1.2, Y1.1
unnamed: C17.1, U1.3, Y1.3
unnamed: R4.1, U1.6
unnamed: R8.1, U4.1
VBUS: C1.1, J1.A4, J1.A9, J1.B4, J1.B9, U2.5, U3.3

## KiCad design tools/gerber-lvs/tests/data/pre-refill-20261009/rp2040-keypad10/rp2040-keypad10.kicad_pcb

Board: 4 copper layers, 100.0 x 66.0 mm, 47 parts (0 on the bottom side), 38 nets.

Parts:
C1: 10uF; C_0603_1608Metric
C2: 22uF; C_0805_2012Metric
C3, C4, C5, C6, C7, C8, C9, C10, C13, C14, C15: 100nF; C_0402_1005Metric
C11, C12: 1uF; C_0402_1005Metric
C16, C17: 33pF; C_0402_1005Metric
D1: RED; LED_0603_1608Metric
D2: GREEN; LED_0805_2012Metric
J1: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: SWD; PinHeader_1x04_P2.54mm_Vertical
R1, R2: 5.1k; R_0402_1005Metric
R3, R6, R8, R9: 1k; R_0402_1005Metric
R4, R5: 22; R_0402_1005Metric
R7: 10k; R_0402_1005Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10: MX; SW_Cherry_MX_1.00u_PCB
SW11: BOOTSEL; SW_Push_1P1T_XKB_TS-1187A
SW12: RESET; SW_Push_1P1T_XKB_TS-1187A
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U2: USBLC6-2SC6; SOT-23-6
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: W25Q128JVSIQ; SOIC-8_5.3x5.3mm_P1.27mm
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C12.1, C13.1, C14.1, U1.23, U1.45, U1.50
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C15.1, R3.1, R7.1, U1.1, U1.10, U1.22, U1.33, U1.42, U1.43, U1.44, U1.48, U1.49, U3.2, U4.8
/BOOT_SW: R6.2, SW11.1
/CC1: J1.A5, R1.1
/CC2: J1.B5, R2.1
/KEY1: SW1.1, U1.2
/KEY2: SW2.1, U1.3
/KEY3: SW3.1, U1.4
/KEY4: SW4.1, U1.5
/KEY5: SW5.1, U1.6
/KEY6: SW6.1, U1.7
/KEY7: SW7.1, U1.8
/KEY8: SW8.1, U1.9
/KEY9: SW9.1, U1.11
/KEY10: SW10.1, U1.12
/LED: R9.1, U1.37
/LED_A: D2.2, R9.2
/PWR_LED: D1.2, R3.2
/QSPI_SCLK: U1.52, U4.6
/QSPI_SD0: U1.53, U4.5
/QSPI_SD1: U1.55, U4.2
/QSPI_SD2: U1.54, U4.3
/QSPI_SD3: U1.51, U4.7
/QSPI_SS: R6.1, U1.56, U4.1
/RUN: J2.4, R7.2, SW12.1, U1.26
/SWCLK: J2.1, U1.24
/SWDIO: J2.3, U1.25
/USB_DM: R4.2, U1.46
/USB_DN: R4.1, U2.6
/USB_DN_C: J1.A7, J1.B7, U2.1
/USB_DP: R5.1, U2.4
/USB_DP_C: J1.A6, J1.B6, U2.3
/USB_DP_R: R5.2, U1.47
/XIN: C16.1, U1.20, Y1.1
/XOUT: R8.1, U1.21
/XTAL_O: C17.1, R8.2, Y1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.1, D2.1, J1.A1, J1.A12, J1.B1, J1.B12, J1.SH, J2.2, R1.2, R2.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, U1.19, U1.57, U2.2, U3.1, U4.4, Y1.2, Y1.4
VBUS: C1.1, J1.A4, J1.A9, J1.B4, J1.B9, U2.5, U3.3
